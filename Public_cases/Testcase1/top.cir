 R1 Net3 0 10K
 C1 Net2 Net3 100NF
 L1 Net1 Net2 10NH
V1 Net1 0 SINE ( 0.0 1.0 10Khz 0.0S 0.0 )

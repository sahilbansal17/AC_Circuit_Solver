V1 Net1 0 SINE ( 0 10 0.159Khz 0.0S )
 Rx NET2 Net1 10
 Ly NET2 0 10MH
 CX1 NET2 0 1NF
 CX2 NET2 0 1NF
 CX3 NET2 0 1NF
 CX4 NET2 0 1NF

V1 Net1 0 SINE ( 0 10 0.159Khz 0.0S )
 R1 NET2 Net1 10
 L1 NET2 0 10MH
 C1 NET2 0 1NF
 C2 NET2 0 1NF
 C3 NET2 0 1NF
 C4 NET2 0 1NF

 R1 Net1 0 10K
 C1 Net0 Net1 100NF
 L1 Net0 0 10NH
 R2 Net0 0 1K
 C2 Net0 0 10NF
I1 Net0 0 SINE ( 0 1 10Khz 0.0S )

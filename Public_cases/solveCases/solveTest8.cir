R1 NET2 NET3 2.2K
C1 NET3 0 0.000001F
I1 NET1 NET2 SINE ( 0 5 0.090Khz 0.0S 0 )
V2 0 NET1 SINE ( 0 5 0.090Khz 0.0S 0 )

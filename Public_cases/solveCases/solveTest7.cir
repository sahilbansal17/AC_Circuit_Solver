R1 NET2 NET3 2.2K
C1 NET3 0 0.000001F
V1 NET2 NET1 SINE ( 0 5 0.06Khz 0.0S 0 )
V2 NET1 0   SINE ( 0 5 0.09Khz 0.0S 0 )
